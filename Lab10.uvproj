# Keil uVision project Lab10.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Lab10
  c flags: Optim=1
  group Source Group 1
    ./: ADC.c dac.c fifo.c Lab10.c Nokia5110.c Resources.c Sound.c UART.c ADC.h dac.h fifo.h Nokia5110.h random.h Sound.h tm4c123gh6pm.h UART.h Print.s random.s startup.s
